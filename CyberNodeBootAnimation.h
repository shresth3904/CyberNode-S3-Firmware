#ifndef CYBERNODE_BOOT_ANIMATION_H
#define CYBERNODE_BOOT_ANIMATION_H

#include <Arduino.h>
#include <U8g2lib.h>
#include <string.h>
#include "DisplayManager.h"
#include "SoundManager.h"
#include "HapticManager.h"
#include "SettingsConfig.h"

#ifndef pgm_read_byte
#define pgm_read_byte(address) (*(const uint8_t *)(address))
#endif

namespace CyberNodeBoot {


static const uint8_t ART_WIDTH = 128;
static const uint8_t ART_HEIGHT = 64;
static const uint8_t ART_BYTES_PER_ROW = 16;

static const uint8_t CYBERNODE_S3_LOCKUP_XBM[1024] PROGMEM = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0xCE, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xFF, 0x7F, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xBF, 0x73, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xDF, 0x39, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xEF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0x63, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0xFE, 0x03, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x00, 0xFE, 0xFC, 0x03, 0x00,
    0x00, 0x00, 0xFF, 0x03, 0x30, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
    0x00, 0x00, 0x03, 0x18, 0xFB, 0xF3, 0xF3, 0x7D, 0xE6, 0xE7, 0xEF, 0x87, 0x03, 0x80, 0x03, 0x00,
    0x00, 0x80, 0x03, 0x18, 0x1B, 0x33, 0x3B, 0xFC, 0x76, 0x76, 0x66, 0x06, 0x7F, 0xF8, 0x01, 0x00,
    0x00, 0x80, 0x03, 0x8C, 0x19, 0xFB, 0x1B, 0xEC, 0x37, 0x36, 0xF6, 0x07, 0xFE, 0xF8, 0x01, 0x00,
    0x00, 0x80, 0x01, 0x8C, 0x0D, 0xFB, 0x18, 0xC6, 0x37, 0x36, 0x36, 0x00, 0xE0, 0x80, 0x01, 0x00,
    0x00, 0x80, 0xFF, 0xFD, 0xFD, 0x39, 0x19, 0x86, 0xF3, 0xF3, 0x33, 0xC2, 0x7F, 0xFE, 0x01, 0x00,
    0x00, 0x00, 0xFF, 0xC0, 0xFD, 0xF9, 0x09, 0x06, 0xF3, 0xF3, 0xF3, 0xC3, 0x3F, 0xFF, 0x00, 0x00,
    0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x77, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
    0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xB8, 0x1B, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xDC, 0x1D, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xEE, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};


static const int16_t ART_X0 = 15,  ART_X1 = 114;    
static const int16_t ART_Y0 = 10,  ART_Y1 = 55;
static const int16_t MARK_X0 = 46, MARK_X1 = 81;
static const int16_t MARK_Y0 = 10, MARK_Y1 = 36;
static const int16_t WORD_X0 = 15, WORD_X1 = 114;
static const int16_t WORD_Y0 = 38, WORD_Y1 = 51;
static const int16_t RULE_Y0 = 51, RULE_Y1 = 56;
static const int16_t CENTER_X = 64;
static const int16_t MARK_CENTER_Y = (MARK_Y0 + MARK_Y1) / 2;   
static const int16_t RULE_HALF = 50;                              
static const int16_t MARK_HALF = (MARK_Y1 - MARK_Y0) / 2;         
static const int16_t WORD_COLS = WORD_X1 - WORD_X0;               
static const int16_t ART_COLS = ART_X1 - ART_X0;                  

class Animation {
public:
    
    
    
    static void run(DisplayManager& displayManager,
                    SoundManager& soundManager,
                    HapticManager& hapticManager,
                    uint8_t buzzerPin,
                    uint8_t animationStyle) {
        soundManager.stop();
        const bool staged =
            (animationStyle == CyberNodeSettings::BOOT_LOGO_ANIMATION_GLITCH);

        
        drawBlank(displayManager);
        serviceFor(hapticManager, 150);

        if (staged) {
            
            playTick(buzzerPin, soundManager);
            for (uint8_t s = 1; s <= 10; ++s) {
                drawScene(displayManager, scaled(RULE_HALF, s, 10), 0, 0);
                serviceFor(hapticManager, 18);
            }
            serviceFor(hapticManager, 60);

            
            for (uint8_t s = 1; s <= 12; ++s) {
                drawScene(displayManager, RULE_HALF, scaled(MARK_HALF, s, 12), 0);
                serviceFor(hapticManager, 22);
            }
            serviceFor(hapticManager, 60);

            
            playTick(buzzerPin, soundManager);
            for (uint8_t s = 1; s <= 14; ++s) {
                drawScene(displayManager, RULE_HALF, MARK_HALF,
                          scaled(WORD_COLS, s, 14));
                serviceFor(hapticManager, 20);
            }
        } else {
            
            playTick(buzzerPin, soundManager);
            for (uint8_t s = 1; s <= 18; ++s) {
                drawWipeScene(displayManager, scaled(ART_COLS, s, 18));
                serviceFor(hapticManager, 20);
            }
        }

        
        drawFinal(displayManager, 16);
        hapticManager.trigger(HapticEvent::BOOT);
        playChime(buzzerPin, soundManager, hapticManager);
        serviceFor(hapticManager, 240);

        
        serviceFor(hapticManager, 1100);

        
        for (int8_t level = 14; level >= 0; level -= 2) {
            drawFinal(displayManager, (uint8_t)level);
            serviceFor(hapticManager, 26);
        }
        drawBlank(displayManager);

        noTone(buzzerPin);
        soundManager.stop();
    }

private:
    struct ToneStep {
        uint16_t frequencyHz;
        uint16_t durationMs;
        uint16_t gapMs;
    };

    

    
    static void playTick(uint8_t buzzerPin, SoundManager& sound) {
        if (!sound.isEnabled()) return;
        tone(buzzerPin, 2093, 6);
    }

    
    static void playChime(uint8_t buzzerPin, SoundManager& sound,
                          HapticManager& haptics) {
        static const ToneStep cue[] = {{1319, 60, 30}, {1976, 150, 0}};
        if (!sound.isEnabled()) return;
        for (uint8_t i = 0; i < (uint8_t)(sizeof(cue) / sizeof(cue[0])); ++i) {
            tone(buzzerPin, cue[i].frequencyHz, cue[i].durationMs);
            serviceFor(haptics, cue[i].durationMs);
            noTone(buzzerPin);
            if (cue[i].gapMs) serviceFor(haptics, cue[i].gapMs);
        }
        noTone(buzzerPin);
    }

    

    
    
    static bool ditherPass(uint8_t x, uint8_t y, uint8_t level) {
        static const uint8_t bayer[4][4] = {
            { 0,  8,  2, 10},
            {12,  4, 14,  6},
            { 3, 11,  1,  9},
            {15,  7, 13,  5}
        };
        return bayer[y & 3U][x & 3U] < level;
    }

    
    static void drawRegion(U8G2& oled, int16_t x0, int16_t x1,
                           int16_t y0, int16_t y1, uint8_t level = 16) {
        if (x0 < 0) x0 = 0;
        if (y0 < 0) y0 = 0;
        if (x1 > ART_WIDTH) x1 = ART_WIDTH;
        if (y1 > ART_HEIGHT) y1 = ART_HEIGHT;
        if (x1 <= x0 || y1 <= y0 || level == 0) return;

        for (int16_t y = y0; y < y1; ++y) {
            const uint16_t row = (uint16_t)y * ART_BYTES_PER_ROW;
            for (int16_t bx = x0 >> 3; bx <= ((x1 - 1) >> 3); ++bx) {
                const uint8_t packed =
                    pgm_read_byte(&CYBERNODE_S3_LOCKUP_XBM[row + bx]);
                if (!packed) continue;
                for (uint8_t bit = 0; bit < 8; ++bit) {
                    if (!(packed & (uint8_t)(1U << bit))) continue;
                    const int16_t x = (int16_t)(bx * 8 + bit);
                    if (x < x0 || x >= x1) continue;
                    if (level < 16 && !ditherPass((uint8_t)x, (uint8_t)y, level)) {
                        continue;
                    }
                    oled.drawPixel((uint8_t)x, (uint8_t)y);
                }
            }
        }
    }

    
    static int16_t scaled(int16_t value, uint8_t step, uint8_t total) {
        const uint16_t t = (uint16_t)step * 256U / total;
        const uint16_t inv = 256U - t;
        const uint16_t ease = 256U - ((inv * inv) >> 8);
        return (int16_t)(((int32_t)value * ease) >> 8);
    }

    

    static void drawBlank(DisplayManager& dm) {
        dm.bootDisplay().clearBuffer();
        dm.presentBootFrame();
    }

    
    
    
    static void drawScene(DisplayManager& dm, int16_t ruleHalf,
                          int16_t markHalf, int16_t wordCols) {
        U8G2& oled = dm.bootDisplay();
        oled.clearBuffer();

        drawRegion(oled, CENTER_X - ruleHalf, CENTER_X + ruleHalf,
                   RULE_Y0, RULE_Y1);

        if (markHalf > 0) {
            const int16_t y0 = MARK_CENTER_Y - markHalf;
            const int16_t y1 = MARK_CENTER_Y + markHalf;
            drawRegion(oled, MARK_X0, MARK_X1, y0, y1);
            if (markHalf < MARK_HALF) {
                oled.drawHLine(MARK_X0, y0, MARK_X1 - MARK_X0);
                oled.drawHLine(MARK_X0, y1 - 1, MARK_X1 - MARK_X0);
            }
        }

        if (wordCols > 0) {
            drawRegion(oled, WORD_X0, WORD_X0 + wordCols, WORD_Y0, WORD_Y1);
            if (wordCols < WORD_COLS) {
                oled.drawVLine(WORD_X0 + wordCols, WORD_Y0, WORD_Y1 - WORD_Y0);
            }
        }
        dm.presentBootFrame();
    }

    
    static void drawWipeScene(DisplayManager& dm, int16_t cols) {
        U8G2& oled = dm.bootDisplay();
        oled.clearBuffer();
        drawRegion(oled, ART_X0, ART_X0 + cols, ART_Y0, ART_Y1);
        if (cols < ART_COLS) {
            oled.drawVLine(ART_X0 + cols, ART_Y0, ART_Y1 - ART_Y0);
        }
        dm.presentBootFrame();
    }

    
    static void drawFinal(DisplayManager& dm, uint8_t level) {
        U8G2& oled = dm.bootDisplay();
        oled.clearBuffer();
        drawRegion(oled, 0, ART_WIDTH, 0, ART_HEIGHT, level);
        dm.presentBootFrame();
    }

    static void serviceFor(HapticManager& haptics, uint16_t durationMs) {
        const uint32_t deadline = millis() + durationMs;
        while ((int32_t)(millis() - deadline) < 0) {
            haptics.update(millis());
            delay(8);
        }
    }
};

} 

#endif 